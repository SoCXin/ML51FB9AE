# Keil uVision project LCD_Interrupt.uvproj, settings and files
target Target (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: LCD_Blinking +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: LCD_INT.C
  group Common
    ../../../../Library/StdDriver/src/: common.c Delay.c lcd.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
