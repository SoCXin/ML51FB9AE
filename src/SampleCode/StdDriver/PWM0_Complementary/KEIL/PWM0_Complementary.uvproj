# Keil uVision project PWM0_Complementary.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: PWM_Complementary +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: PWM0_Complementary.c
  group Library
    ../../../../Library/StdDriver/src/: common.c pwm0.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
