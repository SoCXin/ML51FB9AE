# Keil uVision project TouchKey.uvproj, settings and files
target TK_FreeRun (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: TK_FreeRun +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: DEMO_FREERUN BOARD_TIM
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\StdDriver\lib
  group Source Group 1
    ../../../../Library/StdDriver/src/: common.c
    ../: TK_DebugUART.c TK_MultPinFunctions.c TK_SysTick.c TK_Led.c TK_Main.c TK_UartCmd.c TK_MassProduction.c
  group Library
    ../../../../Library/StdDriver/lib/: TKLib_Calibration.LIB TKLib_FreeRun.LIB TKLib_MassProduction.LIB
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
target TK_Calibration (MCS-51)
  device: ML51PC0AE Nuvoton
  cpu: as above
  output: TK_Calibration +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c define: DEMO_CALIBRATION BOARD_TIM MASS_FINETUNE
  c include: as above
