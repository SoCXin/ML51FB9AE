# Keil uVision project ADC_multi.uvproj, settings and files
target Regbased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: ADC_Multi +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: ADC_multi.C
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c delay.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
